Commit message: Changed download locations in scripts to the new dropbox account.

File: cart/cart_sim/data/scenes/cart2.urdf (robot description, URDF)
Before this commit: robot cart2, 1 links, 0 joints
Links:
- link base_link: geometry visual mesh filename=package://cart_sim/data/robot/cart2.wrl
